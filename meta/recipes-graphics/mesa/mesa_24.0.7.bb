require ${BPN}.inc

inherit recipe-upgrade-additional-rename
RECIPE_UPGRADE_ADDITIONAL_RENAME = "mesa-gl_{pv}.bb"
