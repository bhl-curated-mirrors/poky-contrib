require glib.inc
PACKAGES = ""
PACKAGECONFIG = ""

RECIPE_NO_UPDATE_REASON = "Upgrades are handled in base glib-2.0 recipe"
