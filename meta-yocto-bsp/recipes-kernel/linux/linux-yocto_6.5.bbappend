# TODO bruce will kill me for this
KBUILD_DEFCONFIG:generic-arm64 = "defconfig"
KCONFIG_MODE:generic-arm64 = "--alldefconfig"

COMPATIBLE_MACHINE:generic-arm64 = "generic-arm64"
