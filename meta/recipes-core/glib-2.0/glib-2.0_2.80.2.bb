require glib.inc

inherit recipe-upgrade-additional-rename
RECIPE_UPGRADE_ADDITIONAL_RENAME = "glib-2.0-initial_{pv}.bb"
